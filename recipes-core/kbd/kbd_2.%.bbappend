CFLAGS += "-Wno-error=format-security"

#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
#SRC_URI_append = " \
#     file://add_missing_string_format.patch \
#     "
